# Keil uVision project 2021F.uvprojx, settings and files
target 2021F (6070000::V6.7::.\ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 2021F +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../grayscale;../Log;../Motor_AT4950;../SPI_OLED;../MPU_9250;../control;../PID_Node;../multikey;../protocol;../static_queue;../static_stack;../HSM;../APP_protocol;../app_log;../app_hsm;../app_timer
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group SPI_OLED
    ../SPI_OLED/: bmp.h oled.c oled.h oledfont.h
  group MPU_9250
    ../MPU_9250/: MadgwickAHRS.c MadgwickAHRS.h mpu6050.c mpu6050.h mpu6050_user.c mpu6050_user.h
  group Motor_AT4950
    ../Motor_AT4950/: Motor_AT4950.c
  group PID_Node
    ../PID_Node/: PID_Node.c PID_Node.h
  group Log
    ../Log/: Log.c Log.h
  group multikey
    ../multikey/: multikey.c multikey.h
  group grayscale
    ../grayscale/: grayscale.c grayscale.h
  group control
    ../control/: control.c control.h
  group protocol
    ../protocol/: protocol.c protocol.h
  group static_queue
    ../static_queue/: static_queue.h
  group static_stack
    ../static_stack/: static_stack.h
  group HSM
    ../HSM/: HSM_Core.cpp HSM_Bus.cpp
  group APP_Protocol
    ../APP_protocol/: app_protocol.c
  group app_log
    ../app_log/: app_log.c
  group app_hsm
    ../app_hsm/: app_fsm.c
  group app_timer
    ../app_timer/: app_timer.c
software components: CMSIS:CORE 5.0.1

# Keil uVision project F411test.uvprojx, settings and files
target F411test (6070000::V6.7::.\ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: F411test +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../ZDT_Motor_Serial;../static_queue;../Log;../SPI_OLED;../multikey;../MPU_9250;../PID_fibric;../HSM;../protocol;../app_protocol;../app_menu;../Task_Control
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group ZDT
    ../ZDT_Motor_Serial/: ZDT_Motor_Serial.c
  group Static_queue
    ../static_queue/: static_queue.h
  group Log
    ../Log/: Log.c Log.h
  group OLED
    ../SPI_OLED/: oled.c oled.h oledfont.h
  group MPU6050
    ../MPU_9250/: MadgwickAHRS.c MadgwickAHRS.h mpu6050.c mpu6050.h mpu6050_user.c mpu6050_user.h
  group multikeys
    ../multikey/: multikey.c multikey.h
  group PID_Controller
    ../PID_fibric/: PID_Node.c PID_Node.h
  group app_protocol
    ../app_protocol/: app_protocol.c
  group protocol
    ../protocol/: protocol.c
  group app_menu
    ../app_menu/: app_menu.c
  group Task_Control
    ../Task_Control/: Task_Control.c
software components: CMSIS:CORE 5.0.1

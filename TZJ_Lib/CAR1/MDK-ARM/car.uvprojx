# Keil uVision project car.uvprojx, settings and files
target CAR (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: car +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../control;../grayscale;../key_control;../Log;../Motor_AT4950;../MPU_9250;../multikey;../Protothreads;../SPI_OLED;../speed_control;..\PID_Node;..\angle_control
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group control
    ../control/: control.c control.h
  group grayscale
    ../grayscale/: grayscale.c grayscale.h
  group key_control
    ../key_control/: key_control.c key_control.h
  group Log
    ../Log/: Log.c Log.h
  group Motor_AT4950
    ../Motor_AT4950/: Motor_AT4950.c Motor_AT4950.h
  group MPU_9250
    ../MPU_9250/: MadgwickAHRS.c MadgwickAHRS.h mpu6050.c mpu6050.h mpu6050_user.c mpu6050_user.h
  group multikey
    ../multikey/: multikey.c multikey.h
  group PID_Node
    ../PID_Node/: PID_Node.c PID_Node.h
  group Protothreads
    ../Protothreads/: Protothreads.c Protothreads.h
  group SPI_OLED
    ../SPI_OLED/: bmp.h oled.c oled.h oledfont.h
  group speed_control
    ../speed_control/: speed_control.c speed_control.h
software components: CMSIS:CORE 5.0.1
